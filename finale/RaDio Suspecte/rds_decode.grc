options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rds_decode
    output_language: python
    title: Stereo FM receiver and RDS Decoder
  states: {}

blocks:
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label0: 89.6MHz
    label1: 89.8MHz
    label2: 90.0MHz
    num_opts: '3'
    option1: '89800000'
    option2: '90000000'
    type: int
    value: '89600000'
    widget: radio_buttons
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: freq-freq_tune
  states: {}
- name: freq_tune
  id: variable
  parameters:
    value: '89800000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-20'
    step: '1'
    stop: '5'
    value: '-3'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/simon/Documents/FCSC/writeups-FCSC-2020/finale/RaDio Suspecte/capture.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(1.*(volume)/10)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(1.*(volume)/10)
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '600000'
    type: complex
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '2'
    differential: 'False'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '4'
    timing_bw: 6.28/100.0
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: firdes.low_pass(1.0,240000,13e3,3e3,firdes.WIN_HAMMING)
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 80000, 20000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: '1'
    samp_rate: '250000'
    taps: firdes.low_pass(2500.0,250000,2.6e3,2e3,firdes.WIN_HAMMING)
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '38000'
    decim: '5'
    samp_rate: '240000'
    taps: firdes.low_pass(1.0,240000,13e3,3e3,firdes.WIN_HAMMING)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: L+R
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: L-R
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: RDS
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 19000/250e3
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_1
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 240000.0/250000
    type: fff
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@6
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '250000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: '19000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@5
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_2_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '240000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@3
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_4
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@4
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '250000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@2
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '10'
    taps: ''
    type: ccc
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters: {}
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '2'
    gain: '1'
    ntaps: '100'
    samp_rate: '19000'
    sym_rate: '2375'
    type: fir_filter_ccf
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: BB
    label1: Demod
    label2: Waterfall
    label3: L+R
    label4: L-R
    label5: RDS
    label6: Const
    num_tabs: '7'
  states: {}

connections:
- [analog_fm_deemph_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_deemph_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [analog_wfm_rcv_0, '0', pfb_arb_resampler_xxx_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '1']
- [blocks_complex_to_real_0, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_4, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_keep_one_in_n_0, '0', digital_diff_decoder_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [blocks_sub_xx_0, '0', analog_fm_deemph_0_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_psk_demod_0, '0', blocks_keep_one_in_n_0, '0']
- [fir_filter_xxx_1, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_1, '0', blocks_sub_xx_0, '0']
- [fir_filter_xxx_1, '0', qtgui_freq_sink_x_2_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', pfb_arb_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_2, '0', blocks_complex_to_real_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_freq_sink_x_2, '0']
- [pfb_arb_resampler_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [pfb_arb_resampler_xxx_1, '0', fir_filter_xxx_1, '0']
- [pfb_arb_resampler_xxx_1, '0', freq_xlating_fir_filter_xxx_2, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, rds_panel_0, in]
- [root_raised_cosine_filter_0, '0', digital_psk_demod_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
